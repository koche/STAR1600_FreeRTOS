# Keil uVision project STAR-1600.uvprojx, settings and files
target STAR-1600 (ARM-ADS)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STAR-1600 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Library;../example/modbus;../BSP_STM32L4-INNO
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: freertos.c stm32l4xx_it.c adc.c usbd_dfu_if.c i2c.c stm32l4xx_hal_msp.c sd_diskio.c spi.c usbd_conf.c usart.c gpio.c usb_device.c fatfs.c bsp_driver_sd.c rng.c main.c tim.c sdmmc.c usbd_desc.c rtc.c stm32l4xx_hal_timebase_TIM.c dma.c stm32l4xx_callback.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c event_groups.c queue.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_sd.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pcd.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group example
    ../example/modbus/: modbus_sample.c
    ../example/sigfox/: uart_TX_RX_WS211x_sigfox.c
  group Library
    ../Library/: libModbusRTU.lib
  group BSP_STM32L4-INNO
    ../BSP_STM32L4-INNO/: stm32L4_eval.c
software components: CMSIS:CORE 4.1.0
